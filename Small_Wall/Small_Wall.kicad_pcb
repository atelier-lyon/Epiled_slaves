# Repository atelier-lyon/Epiled_slaves

## KiCad design Small_Wall/Small_Wall.kicad_pcb

Board: 2 copper layers, 100.0 x 14.6 mm, 27 parts (0 on the bottom side), 12 nets.

Parts:
C1, C2, C3, C4, C5: 100nF; C_0805_2012Metric
J1, J3: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
J2, J4: Conn_01x03; SolderWirePad_1x03_Corner_SMD
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
U1, U2, U3, U4, U5: IN-PI55TATPRPGPB
kibuzzard-64B1960B, kibuzzard-64B1960B#2: G***; kibuzzard-64B1960B
kibuzzard-64B19658, kibuzzard-64B19658#2: G***; kibuzzard-64B19658

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.1, J2.1, J3.1, J4.1, U1.3 (VSS), U2.3 (VSS), U3.3 (VSS), U4.3 (VSS), U5.3 (VSS)
unnamed: J1.2, JP1.1 (A)
unnamed: J2.2, JP2.1 (A)
unnamed: J3.2, JP8.1 (A)
unnamed: J4.2, JP9.1 (A)
unnamed: JP1.2 (B), JP2.2 (B), JP3.1 (A), U1.4 (DIN)
unnamed: JP3.2 (B), JP4.1 (A), U1.2 (DOUT), U2.4 (DIN)
unnamed: JP4.2 (B), JP5.1 (A), U2.2 (DOUT), U3.4 (DIN)
unnamed: JP5.2 (B), JP6.1 (A), U3.2 (DOUT), U4.4 (DIN)
unnamed: JP6.2 (B), JP7.1 (A), U4.2 (DOUT), U5.4 (DIN)
unnamed: JP7.2 (B), JP8.2 (B), JP9.2 (B), U5.2 (DOUT)
VDD: C1.1, C2.1, C3.1, C4.1, C5.1, J1.3, J2.3, J3.3, J4.3, U1.1 (VDD), U2.1 (VDD), U3.1 (VDD), U4.1 (VDD), U5.1 (VDD)

## KiCad design Small/Small.kicad_pcb

File Small/README.md:

# Small Board
## By Florian "FloRide" Reimat

## About
This is the Small board

## Images:
### [Schematic](Export/Schematics.pdf):

### [PCB](Export/PCB.pdf):
| Front | Bottom |
:------:|:-------:
|| |

### 3D:
| Simple | Detailled |
:------:|:-------:
|| |

## Others:
- [Interactive BOM](Export/ibom/ibom.html) (Download it and use it)

Parts:
C1, C8, C11: 100uF; CP_Radial_D8.0mm_P3.50mm
C2, C9, C10: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C13, C15: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C6: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C16: DNP; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17, C18: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3: M2; MountingHole_2.7mm_M2.5_DIN965_Pad
J1: Conn_Ext_0; QFN_4-M0G
J2: Conn_Alt_0; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Conn_Ext_4; QFN_4-M0G
J4: Conn_Alt_4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: Conn_Ext_8; QFN_4-M0G
J6: Conn_SWD; PinHeader_2x05_P1.27mm_Vertical_SMD
J7: Conn_Alt_8; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8, J9, J10, J11, J12, J13: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical
J14, J15, J16, J17, J18, J19: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J20, J21, J22, J23, J24, J25: Conn_01x03_Female; SolderWirePad_1x03_Corner_SMD
J27: SWD_TAG_Connector; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6: NMOS; SOT-23_Handsoldering
R1, R2, R9, R10, R16, R17: R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 40.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5, R11, R12, R19, R20, R25: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8, R13, R14, R21, R23, R24: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: DNP; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: TBD; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_Push_1P1T_NO_CK_KSC7xxJ
U1: TLVM23625RDNR; QFN-FCMOD11_RDN_TEX
U2: STM32G070KBT6; LQFP-32_7x7mm_P0.8mm
U3: AP7361C-33E; SOT-223-3_TabPin2
U4: TXB0102DCU; VSSOP-8_2.4x2.1mm_P0.5mm
Y1: Crystal_GND24; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C10.1, C13.1, C14.1, C18.1, J6.1 (VTref), J27.1, R21.2, U2.4 (VDD/VDDA), U3.3 (VO), U4.3 (VCCA), U4.6 (OE)
+5V: C4.1, C5.1, C6.1, C9.1, C17.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J24.1, J25.1, R1.1, R2.1, R3.1, R9.1, R10.1, R16.1, R17.1, U1.4 (VOUT), U3.1 (VI), U4.7 (VCCB)
/LED_RET: U2.17 (PB2), U4.4 (A2)
/LED_SIG: U2.18 (PA8), U4.5 (A1)
/NRST: C15.1, J6.10 (~RESET), J27.3, SW1.2, U2.6 (NRST)
/OSC_IN: C12.2, U2.2 (PC14-OSC32_IN), Y1.3
/OSC_OUT: R15.2, U2.3 (PC15-OSC32_OUT)
/SWDCLK: J6.4 (SWDCLK/TCK), J27.4, U2.25 (PA14-BOOT0)
/SWDIO: J6.2 (SWDIO/TMS), J27.2, U2.24 (PA13)
/UART_1_RX: J1.3, J2.3, R5.2, U2.10 (PA3)
/UART_1_TX: J1.2, J2.2, R4.2, U2.9 (PA2)
/UART_2_RX: J3.3, J4.3, R12.2, U2.21 (PA10)
/UART_2_TX: J3.2, J4.2, R11.2, U2.19 (PA9)
/UART_3_RX: J5.3, J7.3, R20.2, U2.8 (PA1)
/UART_3_TX: J5.2, J7.2, R19.2, U2.7 (PA0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, H1.1, H2.1, H3.1, J1.4, J2.4, J3.4, J4.4, J5.4, J6.3 (GND), J6.5 (GND), J6.9 (GNDDetect), J7.4, J8.3, J9.3, J10.3, J11.3, J12.3, J13.3, J14.3, J15.3, J16.3, J17.3, J18.3, J19.3, J20.3, J21.3, J22.3, J23.3, J24.3, J25.3, J27.5, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), R6.2, R7.2, R8.2, R13.2, R14.2, R21.1, R23.2, R24.2, SW1.1, U1.10 (GND), U2.5 (VSS/VSSA), U3.2 (GND), U4.2 (GND), Y1.2, Y1.4
unnamed: C16.2, R15.1, Y1.1
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), Q1.1 (D)
unnamed: D2.2 (A), R2.2
unnamed: D2.1 (K), Q2.1 (D)
unnamed: D3.2 (A), R9.2
unnamed: D3.1 (K), Q3.1 (D)
unnamed: D4.2 (A), R10.2
unnamed: D4.1 (K), Q4.1 (D)
unnamed: D5.2 (A), R16.2
unnamed: D5.1 (K), Q5.1 (D)
unnamed: D6.2 (A), R17.2
unnamed: D6.1 (K), Q6.1 (D)
unnamed: J9.2, J10.2, J15.2, J16.2, J21.2, J22.2
unnamed: J11.2, J12.2, J17.2, J18.2, J23.2, J24.2
unnamed: J13.2, J19.2, J25.2, R25.1
unnamed: J8.2, J14.2, J20.2, R18.2
unnamed: Q1.2 (G), R4.1, R7.1
unnamed: Q2.2 (G), R5.1, R8.1
unnamed: Q3.2 (G), R11.1, R13.1
unnamed: Q4.2 (G), R12.1, R14.1
unnamed: Q5.2 (G), R19.1, R23.1
unnamed: Q6.2 (G), R20.1, R24.1
unnamed: R3.2, R6.1, U1.9 (FB)
unnamed: C7.1, U1.8 (VCC), U1.11 (RT)
unnamed: U1.5 (SW), U1.6 (SW)
unnamed: R18.1, U4.8 (B1)
unnamed: R25.2, U4.1 (B2)
VDD: C1.1, C2.1, C3.1, C8.1, C11.1, J1.1, J2.1, J3.1, J4.1, J5.1, J7.1, U1.2 (EN), U1.3 (VIN)

Notes on the sheet:
UART_2_LEDs
+5V to +3V3 Converter
+5V Bulk Converter
Optionnal
SWD Connector
LEDS DISPLAY
UART_1_LEDs
UART_3_LEDs
MCU Reset
UARTs
MCU Ext Clock (Optionnal)
MCU Regulation
Mounting Holes

Board: 2 copper layers, 110.0 x 95.3 mm, 89 parts (11 on the bottom side), 45 nets.

## KiCad design Middle_Wall/Middle_Wall/Middle_Wall.kicad_pcb

Board: 2 copper layers, 219.6 x 14.6 mm, 59 parts (0 on the bottom side), 24 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C17, C18: 100nF; C_0805_2012Metric
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
J2, J4: Conn_01x03; SolderWirePad_1x03_Corner_SMD
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP21, JP22: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U17, U18: IN-PI55TATPRPGPB
locked: locked; PinHeader_1x03_P2.54mm_Horizontal

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, J1.3, J2.1, J4.1, U1.3 (VSS), U2.3 (VSS), U3.3 (VSS), U4.3 (VSS), U5.3 (VSS), U6.3 (VSS), U7.3 (VSS), U8.3 (VSS), U9.3 (VSS), U10.3 (VSS), U11.3 (VSS), U12.3 (VSS), U13.3 (VSS), U14.3 (VSS), U15.3 (VSS), U17.3 (VSS), U18.3 (VSS), locked.3
unnamed: J1.2, JP1.1 (A)
unnamed: J2.2, JP2.1 (A)
unnamed: JP10.1 (A), locked.2
unnamed: J4.2, JP11.1 (A)
unnamed: JP1.2 (B), JP2.2 (B), JP3.1 (A), U1.4 (DIN)
unnamed: JP3.2 (B), JP4.1 (A), U1.2 (DOUT), U2.4 (DIN)
unnamed: JP4.2 (B), JP5.1 (A), U2.2 (DOUT), U3.4 (DIN)
unnamed: JP5.2 (B), JP6.1 (A), U3.2 (DOUT), U4.4 (DIN)
unnamed: JP6.2 (B), JP7.1 (A), U4.2 (DOUT), U5.4 (DIN)
unnamed: JP7.2 (B), JP8.1 (A), U5.2 (DOUT), U6.4 (DIN)
unnamed: JP8.2 (B), JP9.1 (A), U6.2 (DOUT), U7.4 (DIN)
unnamed: JP10.2 (B), JP11.2 (B), JP18.2 (B), U14.2 (DOUT)
unnamed: JP12.1 (A), JP22.2 (B), U8.4 (DIN), U18.2 (DOUT)
unnamed: JP12.2 (B), JP13.1 (A), U8.2 (DOUT), U9.4 (DIN)
unnamed: JP13.2 (B), JP14.1 (A), U9.2 (DOUT), U10.4 (DIN)
unnamed: JP14.2 (B), JP15.1 (A), U10.2 (DOUT), U11.4 (DIN)
unnamed: JP15.2 (B), JP16.1 (A), U11.2 (DOUT), U12.4 (DIN)
unnamed: JP16.2 (B), JP17.1 (A), U12.2 (DOUT), U13.4 (DIN)
unnamed: JP17.2 (B), JP18.1 (A), U13.2 (DOUT), U14.4 (DIN)
unnamed: JP9.2 (B), JP19.1 (A), U7.2 (DOUT), U15.4 (DIN)
unnamed: JP19.2 (B), JP21.1 (A), U15.2 (DOUT), U17.4 (DIN)
unnamed: JP21.2 (B), JP22.1 (A), U17.2 (DOUT), U18.4 (DIN)
VDD: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, J1.1, J2.3, J4.3, U1.1 (VDD), U2.1 (VDD), U3.1 (VDD), U4.1 (VDD), U5.1 (VDD), U6.1 (VDD), U7.1 (VDD), U8.1 (VDD), U9.1 (VDD), U10.1 (VDD), U11.1 (VDD), U12.1 (VDD), U13.1 (VDD), U14.1 (VDD), U15.1 (VDD), U17.1 (VDD), U18.1 (VDD), locked.1

## Commit log

2023-06-23 [ROOT] Initial commit
2023-06-23 [MID] Add inital schematic
2023-06-26 [SMA] Add inital schematic
2023-07-04 [SMA] Improve schematic
2023-07-11 [SMA] Edit schematic + Add footprints + begin PCB
2023-07-12 [SMA] Improve PCB
2023-07-12 [SMA] Finish PCB
2023-07-14 [SMA][WALL] Add Finished Wall
2023-07-15 [SMA][EXP] Add Small Export v1.0
2023-07-15 [SMA][VIEW] Add Small View v1.0
2023-07-15 [SMA][GER] Add Small Gerber v1.0
2023-07-15 [SMA][ROOT] Add Small README
2023-07-17 WIP middle
2023-07-17 Middle
2023-07-17 MiddleSize Nanoleaf Finished
2023-07-17 Middle_Wall finished, fix on MiddleNanoleaf
2023-07-17 [MID] Fixed Middle
2023-07-18 [SMA][WALL][EXP] Add Small Wall Export v1.0
2023-07-18 [SMA][WALL][VIEW] Add Small Export v1.0
2023-07-18 [SMA][WALL][GER] Add Small Gerber v1.0
2023-07-18 [SMA][WALL][VIEW] Add missing step
2023-11-13 [SMA] Fix many bug
2023-11-13 [MID][WALL] Change files path
2023-11-13 [SMA][WALL] Update wall
2023-11-13 [SMA][GER] Update Gerber files
2023-11-13 [SMA] Update PCB
2023-11-13 [SMA][DXF] Add DXF folder
2023-11-13 [SMA][WALL][GER] Update Gerber
2023-11-13 [SMA][WALL][DXF] Add DXF folder
